Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: M2I_Voorbeeldkantoorgebouw_Constructiefdeel_nl.ifc
Time: 2012-10-15T20:13:29
Written by: Autodesk Revit 2013
Made in: 20120716_1115(x64)

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 3

# IfcBuildingStorey (3)
Name | LongName | Elevation (mm)
T/FDN | T/FDN | -1000
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4267.22

# IfcBeam: IPE-Beams:IPE270:176561 (46)
In: Level 1
Material: Metal - Steel - 345 MPa
Pset_BeamCommon - Reference: IPE-Beams:IPE270; LoadBearing: yes; IsExternal: no; Slope: 0 deg
Name (IPE-Beams:IPE270:IPE270:...) | GrossVolume (mm3)
156204 | 51698375
156257 | 9709400
156258 | 9709400
156259 | 9709400
156260 | 9709400
156261 | 9709400
156262 | 9709400
156317 | 25114160
156318 | 25114160
156319 | 25114160
156320 | 25114160
156321 | 25114160
156322 | 25114160
156323 | 25114160
156356 | 25114160
156357 | 25114160
156358 | 25114160
156359 | 25114160
156360 | 25114160
156361 | 25114160
156362 | 25114160
156395 | 25114160
156396 | 25114160
156397 | 25114160
156398 | 25114160
156399 | 25114160
156400 | 25114160
156433 | 25114160
156434 | 25114160
156435 | 25114160
156436 | 25114160
156437 | 25114160
156438 | 25114160
156439 | 25114160
156440 | 25114160
157135 | 25114160
157136 | 25114160
157137 | 25114160
157138 | 25114160
157139 | 25114160
157140 | 25114160
157173 | 9709400
157174 | 9709400
157175 | 9709400
157176 | 9709400
157177 | 9709400

# IfcBeam: IPE-Beams:IPE400:176706 (182)
Material: Metal - Steel - 345 MPa
Pset_BeamCommon - Reference: IPE-Beams:IPE400; LoadBearing: yes; IsExternal: no; Slope: 0 deg
Name (IPE-Beams:IPE400:IPE400:...) | In | GrossVolume (mm3)
155847 | Level 1 | 94764379
155848 | Level 1 | 94764379
155849 | Level 1 | 94764379
155850 | Level 1 | 94764379
155851 | Level 1 | 94764379
155935 | Level 1 | 94764379
155936 | Level 1 | 94764379
155937 | Level 1 | 94764379
155938 | Level 1 | 94764379
155939 | Level 1 | 94764379
155940 | Level 1 | 94764379
155988 | Level 1 | 94764379
155989 | Level 1 | 94764379
155990 | Level 1 | 94764379
155991 | Level 1 | 94764379
155992 | Level 1 | 94764379
155993 | Level 1 | 94764379
155994 | Level 1 | 94764379
155995 | Level 1 | 94764379
156043 | Level 1 | 94764379
156044 | Level 1 | 94764379
156045 | Level 1 | 94764379
156046 | Level 1 | 94764379
156047 | Level 1 | 94764379
156048 | Level 1 | 94764379
156096 | Level 1 | 94764379
156097 | Level 1 | 94764379
156098 | Level 1 | 94764379
156099 | Level 1 | 94764379
156100 | Level 1 | 94764379
156101 | Level 1 | 94764379
156102 | Level 1 | 94764379
156150 | Level 1 | 94764379
156151 | Level 1 | 94764379
156152 | Level 1 | 94764379
156153 | Level 1 | 94764379
156154 | Level 1 | 94764379
156155 | Level 1 | 94764379
156156 | Level 1 | 94764379
156205 | Level 1 | 94764379
156206 | Level 1 | 94764379
156207 | Level 1 | 94764379
156208 | Level 1 | 94764379
156209 | Level 1 | 94764379
156473 | Level 1 | 81008780
156474 | Level 1 | 81008780
156475 | Level 1 | 81008780
156476 | Level 1 | 81008780
156477 | Level 1 | 81008780
156478 | Level 1 | 81008780
156479 | Level 1 | 81008780
156480 | Level 1 | 81008780
156551 | Level 1 | 81008780
156552 | Level 1 | 81008780
156553 | Level 1 | 81008780
156554 | Level 1 | 81008780
156555 | Level 1 | 46639952
156556 | Level 1 | 46639952
156597 | Level 1 | 81008780
156598 | Level 1 | 81008780
156599 | Level 1 | 81008780
156600 | Level 1 | 81008780
156601 | Level 1 | 81008780
156602 | Level 1 | 81008780
156603 | Level 1 | 81008780
156644 | Level 1 | 81008780
156645 | Level 1 | 81008780
156646 | Level 1 | 81008780
156647 | Level 1 | 81008780
156648 | Level 1 | 81008780
156649 | Level 1 | 81008780
156650 | Level 1 | 81008780
156691 | Level 1 | 73828438
156692 | Level 1 | 73828438
156693 | Level 1 | 73828438
156694 | Level 1 | 73828438
156695 | Level 1 | 73828438
156696 | Level 1 | 73828438
156737 | Level 1 | 59976025
156738 | Level 1 | 59976025
156739 | Level 1 | 59976025
156740 | Level 1 | 59976025
156741 | Level 1 | 59976025
156742 | Level 1 | 59976025
156801 | Level 1 | 59976025
156802 | Level 1 | 59976025
156803 | Level 1 | 59976025
156804 | Level 1 | 59976025
156805 | Level 1 | 59976025
156806 | Level 1 | 59976025
156807 | Level 1 | 59976025
156842 | Level 1 | 59976025
156843 | Level 1 | 59976025
156844 | Level 1 | 59976025
156845 | Level 1 | 59976025
156846 | Level 1 | 59976025
156847 | Level 1 | 59976025
156848 | Level 1 | 59976025
156883 | Level 1 | 59976025
156884 | Level 1 | 59976025
156885 | Level 1 | 59976025
156886 | Level 1 | 59976025
156887 | Level 1 | 59976025
156888 | Level 1 | 59976025
156923 | Level 1 | 59976025
156924 | Level 1 | 59976025
156925 | Level 1 | 59976025
156926 | Level 1 | 59976025
156927 | Level 1 | 59976025
156928 | Level 1 | 59976025
156929 | Level 1 | 59976025
156930 | Level 1 | 59976025
156965 | Level 1 | 59976025
156966 | Level 1 | 59976025
156967 | Level 1 | 59976025
156968 | Level 1 | 59976025
156969 | Level 1 | 59976025
156970 | Level 1 | 59976025
157005 | Level 1 | 59976025
157006 | Level 1 | 59976025
157007 | Level 1 | 59976025
157008 | Level 1 | 59976025
157009 | Level 1 | 59976025
157044 | Level 1 | 81008780
157045 | Level 1 | 81008780
157046 | Level 1 | 81008780
157047 | Level 1 | 81008780
157048 | Level 1 | 81008780
157049 | Level 1 | 81008780
160855 | Level 2 | 45429782
160856 | Level 2 | 45429782
162549 | Level 2 | 52811819
162550 | Level 2 | 52811819
162603 | Level 2 | 69487961
162604 | Level 2 | 69487961
162635 | Level 2 | 54328565
162636 | Level 2 | 54328565
162665 | Level 2 | 55224091
162666 | Level 2 | 55224091
162697 | Level 2 | 57192634
162698 | Level 2 | 57192634
162729 | Level 2 | 52440700
162730 | Level 2 | 52440700
163662 | Level 2 | 45429782
163663 | Level 2 | 45429782
163665 | Level 2 | 52811819
163666 | Level 2 | 52811819
163668 | Level 2 | 69487961
163669 | Level 2 | 69487961
163671 | Level 2 | 54328565
163672 | Level 2 | 54328565
163674 | Level 2 | 55224091
163675 | Level 2 | 55224091
163677 | Level 2 | 57192634
163678 | Level 2 | 57192634
163680 | Level 2 | 52440700
163681 | Level 2 | 52440700
164955 | Level 2 | 45429782
164956 | Level 2 | 52811819
164957 | Level 2 | 69487961
164958 | Level 2 | 54328565
164959 | Level 2 | 55224091
164960 | Level 2 | 57192634
164961 | Level 2 | 52440700
165447 | Level 2 | 45429782
165448 | Level 2 | 52811819
165449 | Level 2 | 69487961
165450 | Level 2 | 54328565
165451 | Level 2 | 55224091
165452 | Level 2 | 57192634
165453 | Level 2 | 52440700
166699 | Level 1 | 73747760
166700 | Level 1 | 73747760
166701 | Level 1 | 73747760
166702 | Level 1 | 73747760
166703 | Level 1 | 73747760
167003 | Level 1 | 33674997
167004 | Level 1 | 33674997
167533 | Level 1 | 52440700
167787 | Level 1 | 33755675
167788 | Level 1 | 33755675
167789 | Level 1 | 33755675

# IfcBeam: IPE-Beams:IPE450:177997, IPE-Beams:IPE450:IPE450:150970
In: Level 1
Material: Metal - Steel - 345 MPa
BaseQuantities - GrossVolume: 111153170 mm3
Pset_BeamCommon - Reference: IPE-Beams:IPE450; LoadBearing: yes; IsExternal: no; Slope: 0 deg

# IfcBeam: IPE-Beams:IPE500:179059 (119)
Material: Metal - Steel - 345 MPa
Pset_BeamCommon - Reference: IPE-Beams:IPE500; LoadBearing: yes; IsExternal: no; Slope: 0 deg
Name (IPE-Beams:IPE500:IPE500:...) | In | GrossVolume (mm3)
150752 | Level 1 | 130686426
150787 | Level 1 | 130686426
150827 | Level 1 | 130686426
150851 | Level 1 | 130686426
150888 | Level 1 | 130686426
150930 | Level 1 | 130686426
150998 | Level 1 | 130686426
151091 | Level 1 | 63197882
151109 | Level 1 | 111635438
151127 | Level 1 | 82505862
151143 | Level 1 | 71957984
151159 | Level 1 | 78539234
151179 | Level 1 | 75812876
151199 | Level 1 | 74572606
151215 | Level 1 | 95567801
151229 | Level 1 | 72471970
151243 | Level 1 | 62248126
151257 | Level 1 | 82505862
151272 | Level 1 | 111635438
151287 | Level 1 | 63197882
151304 | Level 1 | 62248126
151370 | Level 1 | 72471970
151387 | Level 1 | 95567801
151400 | Level 1 | 74572606
151413 | Level 1 | 75812876
151430 | Level 1 | 78539234
151443 | Level 1 | 71957984
151478 | Level 1 | 78539234
151493 | Level 1 | 75812876
151506 | Level 1 | 74572606
151519 | Level 1 | 95567801
151534 | Level 1 | 72471970
151549 | Level 1 | 63074972
151583 | Level 1 | 62248126
151600 | Level 1 | 72471970
151615 | Level 1 | 95567801
151626 | Level 1 | 74572606
151645 | Level 1 | 75812876
151658 | Level 1 | 78539234
151671 | Level 1 | 71957984
151752 | Level 1 | 111635438
151765 | Level 1 | 82505862
151790 | Level 1 | 82505862
151807 | Level 1 | 111635438
151858 | Level 1 | 111635438
151873 | Level 1 | 82505862
151905 | Level 1 | 82505862
151922 | Level 1 | 111635438
151993 | Level 1 | 111635438
152008 | Level 1 | 82505862
152032 | Level 1 | 82505862
152049 | Level 1 | 111635438
152104 | Level 1 | 62248126
152121 | Level 1 | 72471970
152136 | Level 1 | 95567801
152149 | Level 1 | 74572606
152162 | Level 1 | 75812876
152175 | Level 1 | 78539234
152188 | Level 1 | 71957984
158888 | Level 2 | 130686426
158921 | Level 2 | 130686426
158955 | Level 2 | 130686426
158980 | Level 2 | 130686426
159017 | Level 2 | 130686426
159041 | Level 2 | 130686426
159065 | Level 2 | 130686426
159093 | Level 2 | 130686426
159147 | Level 2 | 82505862
159176 | Level 2 | 82505862
159202 | Level 2 | 82505862
159236 | Level 2 | 82505862
159278 | Level 2 | 82505862
159313 | Level 2 | 82505862
159352 | Level 2 | 82505862
159381 | Level 2 | 82505862
159486 | Level 2 | 62248126
159500 | Level 2 | 72471970
159514 | Level 2 | 95567801
159526 | Level 2 | 74572606
159540 | Level 2 | 75812876
159554 | Level 2 | 78539234
159566 | Level 2 | 71957984
159597 | Level 2 | 71957984
159612 | Level 2 | 78539234
159625 | Level 2 | 75812876
159638 | Level 2 | 74572606
159651 | Level 2 | 95567801
159664 | Level 2 | 72471970
159679 | Level 2 | 62248126
159706 | Level 2 | 62248126
159723 | Level 2 | 72471970
159734 | Level 2 | 95567801
159749 | Level 2 | 74572606
159762 | Level 2 | 75812876
159775 | Level 2 | 78539234
159790 | Level 2 | 71957984
159817 | Level 2 | 63197882
159835 | Level 2 | 111635438
159855 | Level 2 | 71957984
159868 | Level 2 | 78539234
159883 | Level 2 | 75812876
159898 | Level 2 | 74572606
159909 | Level 2 | 95567801
159924 | Level 2 | 72471970
159941 | Level 2 | 62248126
159963 | Level 2 | 111635438
159978 | Level 2 | 63197882
160030 | Level 2 | 62248126
160047 | Level 2 | 72471970
160062 | Level 2 | 95567801
160077 | Level 2 | 74572606
160090 | Level 2 | 75812876
160103 | Level 2 | 78539234
160116 | Level 2 | 71957984
166525 | Level 1 | 62918542
167159 | Level 1 | 75243022
167182 | Level 1 | 25855710
167219 | Level 1 | 45074302
167532 | Level 1 | 72784830

# IfcBeam: M_W-Wide Flange:W360X44:161986 (8)
In: Level 1
Material: Metal - Steel - 345 MPa
Pset_ManufacturerTypeInformation - ModelReference: ModelReference; ModelLabel: ModelLabel; Manufacturer: Manufacturer; ProductionYear: ProductionYear
Pset_BeamCommon - Reference: Reference; LoadBearing: yes; IsExternal: no; Slope: 0 deg
Name (M_W-Wide Flange:W360X44:W360X44:...) | GrossVolume (mm3)
151735 | 31934484
151820 | 31934484
151841 | 31934484
151954 | 31934484
151976 | 31934484
152064 | 31934484
166806 | 23566285
167534 | 23622737

# IfcColumn: HE260A (80)
Type - ElementType: HE260A; PredefinedType: COLUMN; Classification:  (UniFormat)
Material: Metal - Steel - 345 MPa
BaseQuantities - CrossSectionArea: 8682.27 mm2
Pset_ColumnCommon - Reference: H-Wide Flange-Column:HE260A; IsExternal: no; LoadBearing: yes; Slope: 0 deg
Name (H-Wide Flange-Column:HE260A:HE260A:...) | In | Length (mm) | OuterSurfaceArea (mm2) | GrossVolume (mm3)
143837 | T/FDN | 5267.22 | 7832848 | 43125372
144015 | T/FDN | 5267.22 | 7832848 | 43125372
144108 | T/FDN | 5267.22 | 7832848 | 43125372
144211 | T/FDN | 5267.22 | 7832848 | 43125372
144318 | T/FDN | 5267.22 | 7832848 | 43125372
144443 | T/FDN | 5267.22 | 7832848 | 43125372
144444 | T/FDN | 5267.22 | 7832848 | 43125372
144445 | T/FDN | 5267.22 | 7832848 | 43125372
144446 | T/FDN | 5267.22 | 7832848 | 43125372
144447 | T/FDN | 4567.22 | 6794191 | 37394122
144448 | T/FDN | 4567.22 | 6794191 | 37394122
144449 | T/FDN | 4567.22 | 6794191 | 37394122
144450 | T/FDN | 5267.22 | 7832848 | 43125372
144451 | T/FDN | 4567.22 | 6794191 | 37394122
144452 | T/FDN | 4567.22 | 6794191 | 37394122
144453 | T/FDN | 4567.22 | 6794191 | 37394122
144454 | T/FDN | 5267.22 | 7832848 | 43125372
144455 | T/FDN | 4567.22 | 6794191 | 37394122
144456 | T/FDN | 4567.22 | 6794191 | 37394122
144457 | T/FDN | 4567.22 | 6794191 | 37394122
144458 | T/FDN | 5267.22 | 7832848 | 43125372
144459 | T/FDN | 4567.22 | 6794191 | 37394122
144460 | T/FDN | 4567.22 | 6794191 | 37394122
144461 | T/FDN | 4567.22 | 6794191 | 37394122
144462 | T/FDN | 5267.22 | 7832848 | 43125372
144463 | T/FDN | 5267.22 | 7832848 | 43125372
144464 | T/FDN | 5267.22 | 7832848 | 43125372
144465 | T/FDN | 5267.22 | 7832848 | 43125372
144466 | T/FDN | 5267.22 | 7832848 | 43125372
144467 | T/FDN | 5267.22 | 7832848 | 43125372
144468 | T/FDN | 5267.22 | 7832848 | 43125372
144469 | T/FDN | 5267.22 | 7832848 | 43125372
144470 | T/FDN | 5267.22 | 7832848 | 43125372
144471 | T/FDN | 4567.22 | 6794191 | 37394122
144472 | T/FDN | 4567.22 | 6794191 | 37394122
144473 | T/FDN | 4567.22 | 6794191 | 37394122
144474 | T/FDN | 5267.22 | 7832848 | 43125372
144475 | T/FDN | 4567.22 | 6794191 | 37394122
144476 | T/FDN | 4567.22 | 6794191 | 37394122
144477 | T/FDN | 4567.22 | 6794191 | 37394122
149316 | Level 2 | 3657.6 | 5444498 | 29946600
149549 | Level 2 | 3657.6 | 5444498 | 29946600
149550 | Level 2 | 3657.6 | 5444498 | 29946600
149551 | Level 2 | 3657.6 | 5444498 | 29946600
149552 | Level 2 | 3657.6 | 5444498 | 29946600
149553 | Level 2 | 3657.6 | 5444498 | 29946600
149554 | Level 2 | 3657.6 | 5444498 | 29946600
149555 | Level 2 | 3657.6 | 5444498 | 29946600
149556 | Level 2 | 3657.6 | 5444498 | 29946600
149557 | Level 2 | 3657.6 | 5444498 | 29946600
149558 | Level 2 | 3657.6 | 5444498 | 29946600
149559 | Level 2 | 3657.6 | 5444498 | 29946600
149560 | Level 2 | 3657.6 | 5444498 | 29946600
149561 | Level 2 | 3657.6 | 5444498 | 29946600
149562 | Level 2 | 3657.6 | 5444498 | 29946600
149563 | Level 2 | 3657.6 | 5444498 | 29946600
149564 | Level 2 | 3657.6 | 5444498 | 29946600
149565 | Level 2 | 3657.6 | 5444498 | 29946600
149566 | Level 2 | 3657.6 | 5444498 | 29946600
149567 | Level 2 | 3657.6 | 5444498 | 29946600
149568 | Level 2 | 3657.6 | 5444498 | 29946600
149569 | Level 2 | 3657.6 | 5444498 | 29946600
149570 | Level 2 | 3657.6 | 5444498 | 29946600
149571 | Level 2 | 3657.6 | 5444498 | 29946600
149572 | Level 2 | 3657.6 | 5444498 | 29946600
149573 | Level 2 | 3657.6 | 5444498 | 29946600
149574 | Level 2 | 3657.6 | 5444498 | 29946600
149575 | Level 2 | 3657.6 | 5444498 | 29946600
149576 | Level 2 | 3657.6 | 5444498 | 29946600
149577 | Level 2 | 3657.6 | 5444498 | 29946600
149578 | Level 2 | 3657.6 | 5444498 | 29946600
149579 | Level 2 | 3657.6 | 5444498 | 29946600
149580 | Level 2 | 3657.6 | 5444498 | 29946600
149581 | Level 2 | 3657.6 | 5444498 | 29946600
149582 | Level 2 | 3657.6 | 5444498 | 29946600
149583 | Level 2 | 3657.6 | 5444498 | 29946600
149584 | Level 2 | 3657.6 | 5444498 | 29946600
149585 | Level 2 | 3657.6 | 5444498 | 29946600
149586 | Level 2 | 3657.6 | 5444498 | 29946600
149587 | Level 2 | 3657.6 | 5444498 | 29946600
